# Keil uVision project Blinky.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: XMC4400-F100x512 Infineon
  pack: Infineon.XMC4000_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IROM2(0x0C000000,0x80000) IRAM(0x20000000,0xFFC0) IRAM2(0x1FFFC000,0x4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  group Source Group 1
    ./: main.c
  group Doc
    ./: Abstract.txt
software components: CMSIS:CORE 4.2.0, Device:Startup 1.5.0, Device:XMClib:GPIO 2.1.0
